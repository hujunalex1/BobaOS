#include "charset_conv.hpp"

#include <cstdint>

// Table generated by tools/gen_gbk_table.py (main/core/gbk_table.c).
extern "C" {
extern const uint16_t g_gbk_to_unicode[];
extern const int g_gbk_table_size;
extern const int g_gbk_nlead;   // 126  (lead 0x81..0xFE)
extern const int g_gbk_ntrail;  // 190  (trail 0x40..0x7E, 0x80..0xFE)
}

namespace core {
namespace {

// Append a validated Unicode scalar (including non-BMP) as UTF-8.
void appendUtf8(std::string &out, uint32_t cp)
{
    if (cp < 0x80) {
        out.push_back(static_cast<char>(cp));
    } else if (cp < 0x800) {
        out.push_back(static_cast<char>(0xC0 | (cp >> 6)));
        out.push_back(static_cast<char>(0x80 | (cp & 0x3F)));
    } else if(cp<0x10000) {
        out.push_back(static_cast<char>(0xE0 | (cp >> 12)));
        out.push_back(static_cast<char>(0x80 | ((cp >> 6) & 0x3F)));
        out.push_back(static_cast<char>(0x80 | (cp & 0x3F)));
    } else {
        out.push_back(static_cast<char>(0xF0 | (cp >> 18)));
        out.push_back(static_cast<char>(0x80 | ((cp >> 12) & 0x3F)));
        out.push_back(static_cast<char>(0x80 | ((cp >> 6) & 0x3F)));
        out.push_back(static_cast<char>(0x80 | (cp & 0x3F)));
    }
}

int trailIndex(uint8_t trail)
{
    if (trail >= 0x40 && trail <= 0x7E) return trail - 0x40;
    if (trail >= 0x80 && trail <= 0xFE) return trail - 0x41;
    return -1;
}

} // namespace

bool isValidUtf8(const char *data, size_t len)
{
    const uint8_t *p = reinterpret_cast<const uint8_t *>(data);
    size_t i = 0;
    while (i < len) {
        uint8_t c = p[i];
        if (c < 0x80) {
            i += 1;
            continue;
        }
        int extra;
        uint32_t cp;
        if ((c & 0xE0) == 0xC0) { extra = 1; cp = c & 0x1F; }
        else if ((c & 0xF0) == 0xE0) { extra = 2; cp = c & 0x0F; }
        else if ((c & 0xF8) == 0xF0) { extra = 3; cp = c & 0x07; }
        else return false;  // invalid lead byte

        if (i + extra >= len) return false;
        for (int k = 1; k <= extra; ++k) {
            uint8_t cc = p[i + k];
            if ((cc & 0xC0) != 0x80) return false;  // bad continuation
            cp = (cp << 6) | (cc & 0x3F);
        }
        // Reject overlong / out-of-range encodings.
        if (extra == 1 && cp < 0x80) return false;
        if (extra == 2 && cp < 0x800) return false;
        if (extra == 3 && cp < 0x10000) return false;
        if (cp > 0x10FFFF || (cp>=0xD800 && cp<=0xDFFF)) return false;
        i += extra + 1;
    }
    return true;
}

std::string gbkToUtf8(const char *data, size_t len)
{
    std::string out;
    out.reserve(len + len / 2);
    const uint8_t *p = reinterpret_cast<const uint8_t *>(data);
    size_t i = 0;
    while (i < len) {
        uint8_t c = p[i];
        if (c < 0x80) {
            out.push_back(static_cast<char>(c));
            i += 1;
            continue;
        }
        // Potential GBK double byte.
        if (c >= 0x81 && c <= 0xFE && i + 1 < len) {
            uint8_t trail = p[i + 1];
            int ti = trailIndex(trail);
            if (ti >= 0) {
                int idx = (c - 0x81) * g_gbk_ntrail + ti;
                uint16_t cp = (idx < g_gbk_table_size) ? g_gbk_to_unicode[idx] : 0;
                if (cp != 0) {
                    appendUtf8(out, cp);
                    i += 2;
                    continue;
                }
            }
        }
        // Unmappable byte.
        out.push_back('?');
        i += 1;
    }
    return out;
}

std::string ensureUtf8(const std::string &text)
{
    if (isValidUtf8(text.data(), text.size())) return text;
    return gbkToUtf8(text.data(), text.size());
}

std::string decodeText(const std::string &bytes,bool truncated)
{
    auto byte=[&](size_t i){return static_cast<uint8_t>(bytes[i]);};
    const bool le=bytes.size()>=2 && byte(0)==0xff && byte(1)==0xfe;
    const bool be=bytes.size()>=2 && byte(0)==0xfe && byte(1)==0xff;
    const bool bom=bytes.size()>=3 && byte(0)==0xef && byte(1)==0xbb && byte(2)==0xbf;
    std::string decoded;
    if(le || be) {
        auto word=[&](size_t i)->uint32_t {return le?byte(i)|(byte(i+1)<<8):(byte(i)<<8)|byte(i+1);};
        for(size_t i=2;i+1<bytes.size();i+=2) {
            uint32_t cp=word(i);
            if(cp>=0xD800 && cp<=0xDBFF) {
                if(i+3>=bytes.size() && truncated) break;
                const uint32_t low=i+3<bytes.size()?word(i+2):0;
                if(low>=0xDC00 && low<=0xDFFF) { cp=0x10000+((cp-0xD800)<<10)+low-0xDC00; i+=2; }
                else cp=0xfffd;
            } else if(cp>=0xDC00 && cp<=0xDFFF) cp=0xfffd;
            appendUtf8(decoded,cp);
        }
        if(!truncated && bytes.size()%2) appendUtf8(decoded,0xfffd);
    } else {
        auto text=bytes.substr(bom?3:0);
        if(truncated && !isValidUtf8(text.data(),text.size())) {
            // A partial final code point must not turn an otherwise UTF-8
            // document into a GBK document. Trim only a valid-prefix suffix.
            for(size_t cut=1;cut<=3 && cut<=text.size();++cut) {
                const size_t start=text.size()-cut;
                const auto lead=static_cast<uint8_t>(text[start]);
                const size_t need=lead>=0xC2 && lead<=0xDF?2:lead>=0xE0 && lead<=0xEF?3:lead>=0xF0 && lead<=0xF4?4:0;
                bool continuation=true;
                for(size_t i=start+1;i<text.size();++i)
                    if((static_cast<uint8_t>(text[i])&0xc0)!=0x80) continuation=false;
                if(cut>1) {
                    const auto second=static_cast<uint8_t>(text[start+1]);
                    if((lead==0xE0 && second<0xA0) || (lead==0xED && second>=0xA0) ||
                       (lead==0xF0 && second<0x90) || (lead==0xF4 && second>=0x90)) continuation=false;
                }
                if(need>cut && continuation && isValidUtf8(text.data(),start)) { text.resize(start); break; }
            }
        }
        if(!bom) decoded=ensureUtf8(text);
        else {
            for(size_t i=0;i<text.size();) {
                const auto c=static_cast<uint8_t>(text[i]);
                const size_t n=c<0x80?1:c>=0xC2 && c<=0xDF?2:c>=0xE0 && c<=0xEF?3:c>=0xF0 && c<=0xF4?4:0;
                if(n && i+n<=text.size() && isValidUtf8(text.data()+i,n)) { decoded.append(text,i,n); i+=n; }
                else { appendUtf8(decoded,0xfffd); ++i; }
            }
        }
    }
    std::string out; out.reserve(decoded.size());
    for(size_t i=0;i<decoded.size();++i) {
        const auto c=static_cast<uint8_t>(decoded[i]);
        if(c=='\r') { if(i+1<decoded.size() && decoded[i+1]=='\n') ++i; out+='\n'; }
        else if(c=='\t') out+="    ";
        else if(c<32 && c!='\n') appendUtf8(out,0xfffd);
        else out+=decoded[i];
    }
    return out;
}
} // namespace core